# Keil uVision project scx10.uvprojx, settings and files
target SCX10 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: scx10
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\User;.\project\inc;.\Hardware\TIMER;.\Hardware\usart;.\Hardware\controller;.\Hardware\24CXX;.\Hardware\IIC;.\Hardware\crc;.\Hardware\ADC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c delay.c stm32f10x_it.c
  group FWLIB
    ./project/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Hardware
    ./Hardware/TIMER/: timer.c
    ./Hardware/usart/: usart.c
    ./Hardware/controller/: controller.c
    ./Hardware/24CXX/: 24cxx.c
    ./Hardware/IIC/: myiic.c
    ./Hardware/crc/: crc16.c
    ./Hardware/ADC/: adc.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
